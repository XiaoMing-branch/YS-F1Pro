### uVision2 Project, (C) Keil Software
### Do not modify !

Target (stm32_test), 0x0004 // Tools: 'ARM-ADS'

Group (Startup)
Group (Source Files)
Group (USB LIB)
Group (Common Files)
Group (Read me)

File 1,2,<.\common\startup\stm32f10x_vector.s><stm32f10x_vector.s>
File 2,1,<.\usb_endp.c><usb_endp.c>
File 2,1,<.\usb_istr.c><usb_istr.c>
File 2,1,<.\usb_prop.c><usb_prop.c>
File 2,1,<.\usb_pwr.c><usb_pwr.c>
File 2,1,<.\usb_scsi.c><usb_scsi.c>
File 2,1,<.\fsmc_nand.c><fsmc_nand.c>
File 2,1,<.\hw_config.c><hw_config.c>
File 2,1,<.\main.c><main.c>
File 2,1,<.\mass_mal.c><mass_mal.c>
File 2,1,<.\memory.c><memory.c>
File 2,1,<.\scsi_data.c><scsi_data.c>
File 2,1,<.\sdcard.c><sdcard.c>
File 2,1,<.\stm32f10x_it.c><stm32f10x_it.c>
File 2,1,<.\usb_bot.c><usb_bot.c>
File 2,1,<.\usb_desc.c><usb_desc.c>
File 2,1,<.\usart1_fun.c><usart1_fun.c>
File 3,1,<.\USBLIB\src\usb_core.c><usb_core.c>
File 3,1,<.\USBLIB\src\usb_init.c><usb_init.c>
File 3,1,<.\USBLIB\src\usb_int.c><usb_int.c>
File 3,1,<.\USBLIB\src\usb_mem.c><usb_mem.c>
File 3,1,<.\USBLIB\src\usb_regs.c><usb_regs.c>
File 4,2,<.\common\src\cortexm3_macro.s><cortexm3_macro.s>
File 4,1,<.\common\src\stm32f10x_usart.c><stm32f10x_usart.c>
File 4,1,<.\common\src\lcd.c><lcd.c>
File 4,1,<.\common\src\stm32f10x_flash.c><stm32f10x_flash.c>
File 4,1,<.\common\src\stm32f10x_fsmc.c><stm32f10x_fsmc.c>
File 4,1,<.\common\src\stm32f10x_gpio.c><stm32f10x_gpio.c>
File 4,1,<.\common\src\stm32f10x_lib.c><stm32f10x_lib.c>
File 4,1,<.\common\src\stm32f10x_nvic.c><stm32f10x_nvic.c>
File 4,1,<.\common\src\stm32f10x_rcc.c><stm32f10x_rcc.c>
File 4,1,<.\common\src\stm32f10x_spi.c><stm32f10x_spi.c>
File 4,1,<.\common\src\stm32f10x_systick.c><stm32f10x_systick.c>
File 4,1,<.\common\src\spi_flash.c><spi_flash.c>
File 4,1,<.\stm32f10x_dma.c><stm32f10x_dma.c>
File 4,1,<.\stm32f10x_sdio.c><stm32f10x_sdio.c>
File 5,5,<.\ËµÃ÷.txt><ËµÃ÷.txt>


Options 1,0,0  // Target 'stm32_test'
 Device (STM32F103ZE)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x.s" ("STM32 Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_512 -FS08000000 -FL080000))
 DevID (4216)
 Rgf (stm32f10x_lib.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿST\STM32F10x\)
 OrgReg (ÿST\STM32F10x\)
 TgStat=16
 OutDir (.\output\)
 OutName (Mass_Storage)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\listing\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 ADSFLGA { 243,31,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACPUTYP ("Cortex-M3")
 RVDEV ()
 ADSTFLGA { 0,12,0,2,99,0,0,66,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSIRAM { 0,0,0,0,32,0,0,1,0 }
 OCMADSIROM { 1,0,0,0,8,0,0,8,0 }
 OCMADSXRAM { 0,0,0,0,0,0,0,0,0 }
 OCR_RVCT { 1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,8,0,0,8,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,32,0,0,1,0,0,0,0,0,0,0,0,0,0 }
 RV_STAVEC ()
 ADSCCFLG { 5,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSCMISC ()
 ADSCDEFN ()
 ADSCUDEF ()
 ADSCINCD (.\common\inc;.\USBLIB\inc;..\STM32_Test2(µÚ¶þ½×¶Î£¬ÒÆÖ²È¦È¦µÄNAND³ÌÐò))
 ADSASFLG { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSAMISC ()
 ADSADEFN ()
 ADSAUDEF ()
 ADSAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ADSLDFG { 17,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSLDTA (0x08000000)
 ADSLDDA (0x20000000)
 ADSLDSC ()
 ADSLDIB ()
 ADSLDIC ()
 ADSLDMC ()
 ADSLDIF ()
 ADSLDDW ()
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103ZE)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103ZE)
  OPTDBG 49150,8,()()()()()()()()()() (Segger\JLTAgdi.dll)()()()
 FLASH1 { 9,0,0,0,1,0,0,0,7,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (Segger\JLTAgdi.dll)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

